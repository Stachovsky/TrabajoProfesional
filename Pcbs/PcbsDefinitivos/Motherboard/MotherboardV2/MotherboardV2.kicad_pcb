# Repository Stachovsky/TrabajoProfesional (continued)

## KiCad design Pcbs/PcbsDefinitivos/SensoresHvI_Accionadores/.kicad_pcbVersion1.kicad_pcb

Board: 2 copper layers, 37 parts (8 on the bottom side), 34 nets.

Parts:
1N4148: DIODE; SM0603_Capa
C1: 2200uF; c_elec_10x20
C2: 330uF; SMDHD/VF
D1: BRIDGE; bridge_1KV_TH
D2: BRIDGE; bridge_1A
D3: DIODESCH; SM1206
F1: FUSE; FUSE_1KV_TH
K1: CONN_3; bornier3
L1: 300mH; SMD_inductor
P1: CONN_2; bornier2
P2: CONN_6; PIN_ARRAY_2X1
P3, P4, P6: CONN_2; PIN_ARRAY_2X1
P5: CONN_2; 2PIN_6mm
P7: Sirena; bornier3
P8, P9: CONN_1; 1pin
R1, R3, R5, R6: 10k; SM0805
R2, R4: 1k; SM0805
R7, R8, R9: R; SM0603_Resistor
Rele1: RELEDOBLE; relay_gq-smd-s
Rele2: RELE; relay_gq-smd-s
U1, U3: TL082; SO8E
U2, U4: IL300; DIP-8__300_ELL
U5, U8: PHTRANS; DIP-6__300_ELL
U6: TL2575; TO263-5
U7: DIODE; SM0603_Capa

Connections:
+5V: K1.1, U3.8
+5VA: 1N4148.2, C2.1, L1.2, R2.1, R4.1, Rele1.1, Rele2.2, U6.4, U7.2
/ENABLE_HV_SOURCE: P2.1, R8.2
/SENSOR_V_CAPACITORS: R6.1, U3.7
/SENSOR_V_HV_SOURCE: P2.2, R3.1, U3.1
/V_CAPACITORS: F1.2, P6.1, P9.1, R5.2
/V_HV_SOURCE: D1.3, P8.1, R1.2, R7.1
GND: K1.3, U2.5, U3.3, U3.4, U3.5, U4.5, U5.2, U8.2
GNDA: C1.2, C2.2, D1.1, D2.1, D3.1, P6.2, U1.3, U1.4, U1.5, U2.4, U4.4, U5.4, U6.3, U8.4
unnamed: F1.1, R7.2
unnamed: R3.2, U2.6, U3.2
unnamed: D1.2, P5.1
unnamed: D1.4, P5.2
unnamed: R8.1, U5.1
unnamed: 1N4148.1, Rele1.8, U5.5
unnamed: R6.2, U3.6, U4.6
unnamed: R5.1, U1.6, U4.3
unnamed: U1.7, U4.1
unnamed: R4.2, U4.2
unnamed: R2.2, U2.2
unnamed: U1.1, U2.1
unnamed: P3.2, Rele1.3
unnamed: R1.1, U1.2, U2.3
unnamed: R9.1, U8.1
unnamed: Rele2.1, U7.1, U8.5
unnamed: P7.1, Rele2.3
unnamed: P7.2, Rele2.4
unnamed: D2.2, P1.1
unnamed: C1.1, D2.3, U6.1
unnamed: D2.4, P1.2
unnamed: P4.2, Rele1.7
unnamed: P4.1, Rele1.5
unnamed: P3.1, Rele1.2
unnamed: D3.2, L1.1, U6.2

## KiCad design Pcbs/PcbsDefinitivos/Motherboard/Motherboard.kicad_pcb

Board: 2 copper layers, 49 parts (1 on the bottom side), 60 nets, no tracks yet.

Parts:
3.3k1: R; SM0805
C1, C2, C3, C9: 100nF; SM0805
C4: 4.7uF; c_elec_5x4.5
C5: 2200uf; c_elec_10x10.5
C6: 330uf; c_elec_10x7.7
C7: 1uF; SM0805
C8: 22uF; c_elec_6.3x4.5
D1: BRIDGE; bridge_1A
D2: DIODESCH; SM1206
D3, D5, D6: RED; LED-3MM
D4: GREEN; LED-3MM
L1: 330mH; SMD_inductor
P1, P3: CONN_2; bornier2
P2: CONN_8; SIL-10
P4: CONN_10X2; vasch_strip_10x2
P5: CONN_8; SIL-8
R1: 4.7k; SM0805
R2, R12, R13, R14, R15, R19: 10k; SM0805
R3, R4: 10K; SM0805
R5, R6, R7, R8, R9, R10, R11, R17, R18: 270; SM0805
R16: 560; SM0805
SW1: SW_PUSH_DOUBLE; SW_PUSH-12mm
U1: PRTR5V0U2X; LMB2S
U2: FT232RL; S0IC28N
U3: TL2575; DPAK5
U4: LPCXPRESSO_LPC1769; LPCXpresso1769
U5: NCP1117ST12T3G; DPAK3
U6: CAT811
U7: MMC_SD; SDCARD-REVERSE

Connections:
+5V: C1.2, C2.2, C4.1, C6.1, L1.2, P2.2, P4.1, P5.2, R5.1, R6.1, R16.2, U1.4, U2.4, U2.20, U3.4, U4.2, U5.3
/3.3V: 3.3k1.1, C8.1, C9.1, R3.1, R4.1, R12.1, R13.1, R14.1, R15.1, R17.2, R19.1, U5.2, U6.4, U7.4
/9VAC+: D1.4, P1.2
/9VAC-: D1.2, P1.1
/BTN_RESET: SW1.1, SW1.2, U6.3
/CARD_DETECT: R11.1, U4.52
/CS1: P4.18, U4.11
/CS2: P4.20, U4.12
/Contactor_1: P5.3, U4.27
/Contactor_2: P5.4, U4.26
/Contactor_3: P5.5, U4.25
/DB0: P4.2, U4.38
/DB1: P4.4, U4.39
/DB2: P4.6, U4.40
/DB3: P4.8, U4.41
/DB4: P4.10, U4.42
/DB5: P4.12, U4.43
/DB6: P4.14, U4.45
/DB7: P4.16, U4.46
/E: P4.15, U4.47
/EMERGENCY_STOP: 3.3k1.2, C7.1, P3.2, U4.51
/ENABLED_HV_SOURCE: P2.8, U4.20
/ENABLED_SIRENA: P2.7, U4.21
/Green_Light: P5.6, U4.24
/MISO: R10.1, U4.6
/MOSI: R8.1, U4.5
/R/W: P4.17, U4.48
/RESET_MICRO: R18.1, U6.2
/RESET_USB_UART: R1.2, R2.1, U2.19
/RS: P4.19, U4.13
/RX_3: R3.2, U2.1, U4.10
/Red_Light: P5.8, U4.22
/SCK: R9.1, U4.7
/SENSOR_I: P2.4, U4.17
/SENSOR_V_CAPACITORS: P2.5, U4.16
/SENSOR_V_HV_SOURCE: P2.6, U4.15
/SSEL: R7.1, U4.44
/STATUS_LED: P4.5, U4.8
/TX_3: U2.5, U4.9
/USB+: P4.9, U1.2, U2.15
/USB-: P4.11, U1.3, U2.16
/USB_VCC: P4.7, R1.1
/Yellow_Light: P5.7, U4.23
/~RST: P4.13, U4.14
GND: C1.1, C2.1, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, D1.1, D2.1, D5.2, D6.2, P2.1, P3.1, P4.3, P5.1, R2.2, U1.1, U2.7, U2.18, U2.21, U2.25, U2.26, U3.3, U4.1, U4.54, U5.1, U6.1, U7.3, U7.6, U7.11
unnamed: C5.1, D1.3, U3.1
unnamed: D3.2, U2.23
unnamed: D4.2, U2.22
unnamed: C3.1, U2.17
unnamed: D4.1, R6.2
unnamed: D3.1, R5.2
unnamed: R9.2, R13.2, U7.5
unnamed: R11.2, R12.2, U7.10
unnamed: R18.2, R19.2, U4.4
unnamed: D5.1, R16.1
unnamed: D6.1, R17.1
unnamed: R8.2, R14.2, U7.2
unnamed: R10.2, U7.7
unnamed: R7.2, R15.2, U7.1
unnamed: D2.2, L1.1, U3.2

## Commit log

2013-06-25 Primer commmit
