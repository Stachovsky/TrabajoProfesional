# Repository Stachovsky/TrabajoProfesional

File README.md:

TrabajoProfesional
==================

Archivos, codigo y documentacion del trabajo profesional. Proyecto: Sistema de control para sinterizado de nano polvos.

## KiCad design Pcbs/PcbsDefinitivos/Motherboard/MotherboardV2/MotherboardV2.kicad_pcb

Board: 2 copper layers, 106.4 x 157.5 mm, 58 parts (0 on the bottom side), 66 nets.

Parts:
3.3k1: R; SM0805
2200uF1: C14; c_elec_10x10.5
2200uF2: C15; c_elec_10x10.5
C1, C2, C3, C9: 100nF; SM0805
C4: 4.7uF; c_elec_5x4.5
C7: 1uF; SM0805
C8: 22uF; c_elec_6.3x4.5
C10: 100n; SM0805
C11, C13: 2200uF; c_elec_10x10
C12, C16: 0.01u; SM0805
CAT811: VAL**; CAT811
CON_LCD/USB: P4; HE10_20D
CON_SENSORES: P2; he10-10d
D1: BRIDGE; bridge_1A
D3, D5, D6: RED; LED-3MM
D4: GREEN; LED-3MM
P1: CON_ALIMENTACION; bornier3
P3: CON_EMERGENCY; bornier2
P5: CON_BALIZA; SIL-6
P6: CON_CONTACTORES; SIL-5
P7: CON_+/-15V; bornier2
R1: 4.7k; SM0805
R2, R12, R13, R14, R15, R19: 10k; SM0805
R3, R4: 10K; SM0805
R5, R6, R7, R8, R9, R10, R11, R17, R18: 270; SM0805
R16: 560; SM0805
SW1: SW_PUSH_DOUBLE; SW_PUSH-12mm
U1: PRTR5V0U2X; LMB2S
U2: FT232RL; SSOP28
U4: LPCXPRESSO_LPC1769; LPCXpresso1769Thick
U5: NCP1117ST12T3G; DPAK3
U6: CAT811
U7: MMC_SD; SDCARD-REVERSE
U8: LM7815; TO220_VERT
U9: LM7915; TO220_VERT
U10: LM7905; TO220_VERT
U11: LM7805; TO220_VERT

Connections:
+5V: C1.2, C2.2, C4.1, C10.1, CON_LCD/USB.2, CON_SENSORES.2, P5.2, P6.2, R5.1, R6.1, R16.2, U1.4, U2.4, U2.20, U4.2, U5.3, U11.3
-5V: CON_SENSORES.4, U10.3
/3.3V: 3.3k1.1, C8.1, C9.1, CAT811.4, R3.1, R4.1, R12.1, R13.1, R14.1, R15.1, R17.2, R19.1, U5.2, U7.4
/15VAC+: D1.4, P1.3
/15VAC-: D1.2, P1.1
/15VDC+: C11.1, C13.1, D1.3, U8.1
/15VDC-: 2200uF1.2, 2200uF2.2, D1.1, U9.2
/+15V: C12.1, P7.1, U8.3, U11.1
/-15V: C16.1, P7.2, U9.3, U10.2
/BTN_RESET: CAT811.3, SW1.1, SW1.2
/CARD_DETECT: R11.1, U4.52
/CS1: CON_LCD/USB.18, U4.11
/CS2: CON_LCD/USB.20, U4.12
/Contactor_1: P6.3, U4.27
/Contactor_2: P6.4, U4.26
/Contactor_3: P6.5, U4.25
/DB0: CON_LCD/USB.15, U4.38
/DB1: CON_LCD/USB.13, U4.39
/DB2: CON_LCD/USB.11, U4.40
/DB3: CON_LCD/USB.9, U4.41
/DB4: CON_LCD/USB.7, U4.42
/DB5: CON_LCD/USB.5, U4.43
/DB6: CON_LCD/USB.3, U4.45
/DB7: CON_LCD/USB.1, U4.46
/E: CON_LCD/USB.14, U4.47
/EMERGENCY_STOP: 3.3k1.2, C7.1, P3.2, U4.51
/ENABLE_BALIZA: CON_SENSORES.10, U4.21
/ENABLE_HV_SOURCE: CON_SENSORES.9, U4.20
/Green_Light: P5.3, U4.24
/MISO: R10.1, U4.6
/MOSI: R8.1, U4.5
/R/W: CON_LCD/USB.16, U4.48
/RESET_MICRO: CAT811.2, R18.1
/RESET_USB_UART: R1.2, R2.1, U2.19
/RS: CON_LCD/USB.19, U4.13
/RX_3: R3.2, U2.1, U4.10
/Red_Light: P5.5, U4.22
/SCK: R9.1, U4.7
/SENSOR_AUX_0: CON_SENSORES.7, U4.18
/SENSOR_AUX_1: CON_SENSORES.8, U4.19
/SENSOR_I: CON_SENSORES.6, U4.17
/SENSOR_V_CAPACITORS: CON_SENSORES.5, U4.16
/SENSOR_V_HV_SOURCE: CON_SENSORES.3, U4.15
/SIRENA: P5.6, U4.49
/SSEL: R7.1, U4.44
/STATUS_LED: CON_LCD/USB.6, U4.8
/TX_3: U2.5, U4.9
/USB+: CON_LCD/USB.10, U1.2, U2.15
/USB-: CON_LCD/USB.12, U1.3, U2.16
/USB_VCC: CON_LCD/USB.8, R1.1
/Yellow_Light: P5.4, U4.23
/~RST: CON_LCD/USB.17, U4.14
GND: 2200uF1.1, 2200uF2.1, C1.1, C2.1, C3.2, C4.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C16.2, CAT811.1, CON_LCD/USB.4, CON_SENSORES.1, D5.2, D6.2, P1.2, P3.1, P5.1, P6.1, R2.2, U1.1, U2.7, U2.18, U2.21, U2.25, U2.26, U4.1, U4.54, U5.1, U7.3, U7.6, U7.11, U8.2, U9.1, U10.1, U11.2
unnamed: R8.2, R14.2, U7.2
unnamed: R9.2, R13.2, U7.5
unnamed: R10.2, U7.7
unnamed: R11.2, R12.2, U7.10
unnamed: R7.2, R15.2, U7.1
unnamed: R18.2, R19.2, U4.4
unnamed: D5.1, R16.1
unnamed: D6.1, R17.1
unnamed: D4.1, R6.2
unnamed: C3.1, U2.17
unnamed: D3.1, R5.2
unnamed: D3.2, U2.23
unnamed: D4.2, U2.22

## KiCad design Pcbs/PcbsDefinitivos/FuenteAltaTensionSensoresTension/FuenteAltaTensionSensoresTension.kicad_pcb

Parts:
C1, C4, C7, C8: 2200uF
C2, C5: 0.33uF
C3: 0.01uF
C6: 0.1uF
D1: BU2010
D2: LMB2S
D3, D4: LED
D5: HV_PRESENT
F1: FUSE
K1: Sensor_I
K2: 9VAC
K3: Sensores_LV
K4: Sensores_HV
P1, P8, P9: CONN_1
P2: AC_HV_OUT
P3: 220VAC
P4: 220V_HV_SOURCE
P5: 220V_9VAC
P6: DC_HV_OUT
P7: Sirena
P10: CONN_8
R1, R14: 560
R2, R4: 100
R3, R5, R6, R11, R13, R18, R19, R20, R21, R22: 22K
R7: R
R8, R9: 560
R10, R12: 10M
R15: 5.6k
R16: 270
R17: 3.3k
R23, R24: 0
Rele1: ReleFuenteHV
Rele2: ReleSirena
U1, U3: TL082
U2, U4: IL300
U5, U8: 4N25
U6: LM78L05
U7, U10: DIODE
U9: LM79L05

Connections:
/9DC+: C1.1, C2.1, C7.1, D2.3 (+), U6.1 (VIN)
/9DC-: C4.2, C5.1, C8.2, D2.1 (-), U9.2 (VIN)
/9VAC+: D2.4, K2.1
/9VAC-: D2.2, K2.3
/220V+: P3.2 (PM), P5.2 (PM), Rele1.3, Rele2.3
/220V-: P3.1, P5.1, Rele1.2, Rele2.2
/220v+_SOURCE_HV: P4.1, Rele1.5
/220v-_SOURCE_HV: P4.2 (PM), Rele1.7
/DC_HV_OUT+: F1.2, P6.1
/ENABLE_HV_SOURCE: P10.4, R8.2
/ENABLE_SIRENA: P10.2, R9.2
/HV_LED_INDICATOR: P10.6, R16.1
/SENSOR_I: P10.5, R15.2, R17.1
/SENSOR_V_CAPACITORS: P10.3, R22.2, U3.7
/SENSOR_V_HV_SOURCE: P10.1, R18.2, U3.1
/SOURCE_HV_OUT+: D1.4, P2.1
/SOURCE_HV_OUT-: D1.2, P2.2 (PM)
/Sirena+: P7.1, Rele2.5
/Sirena-: P7.2 (PM), Rele2.7
/V_CAPACITORS: P1.1, P9.1, R12.1
/V_CAPACITORS_A: K4.1, R12.2, R13.1
/V_CAPACITORS_B: K3.1, R24.1
/V_HV_SOURCE: D1.3 (+), P8.1, R7.1, R10.1
/V_HV_SOURCE_A: K4.3, R10.2, R11.1
/V_HV_SOURCE_B: K3.3, R23.1
GNDA: C1.2, C2.2, C3.2, C4.1, C5.2, C6.2, C7.2, C8.1, D1.1 (-), D3.1 (A), D4.2 (K), K2.2 (PM), K3.2 (PM), K4.2 (PM), P6.2 (PM), R3.1, R11.2, R13.2, R20.1, U2.1, U4.1, U5.4, U6.2 (GND), U8.4, U9.3 (GND)
unnamed: Rele1.8, U5.5, U10.1 (A)
unnamed: Rele2.8, U7.1 (A), U8.5
unnamed: K1.2 (PM), R17.2
unnamed: R8.1, U5.1
unnamed: R23.2, U1.3
unnamed: R24.2, U1.5
unnamed: R9.1, U8.1
unnamed: R21.2, R22.1, U3.6
unnamed: R5.2, U2.5, U3.3
unnamed: R20.2, U1.6, U4.4
unnamed: R19.2, U3.5, U4.5
unnamed: R6.2, R18.1, U3.2
unnamed: D3.2 (K), R1.2
unnamed: D4.1 (A), R14.2
unnamed: D5.1 (A), R16.2
unnamed: F1.1, R7.2
unnamed: R4.1, U1.7
unnamed: R2.2, U2.2
unnamed: R4.2, U4.2
unnamed: R2.1, U1.1
unnamed: R3.2, U1.2, U2.4

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
Board: 2 copper layers, 233.7 x 160.0 mm, 72 parts (34 on the bottom side), 50 nets.

Other parts of the board:
1PIN, 1PIN#2, 1PIN#3, 1PIN#4, 1PIN#5, 1PIN#6, 1PIN#7, 1PIN#8: P***; 1pin

## KiCad design Pcbs/PcbsDefinitivos/DisplayGraficoConectorUSB/DisplayGraficoConectorUSB.kicad_pcb

Parts:
D1: STATUS_LED
J1: USB
K1: ContrastControl_10k
P1: CONN_10X2
R1: 270
U1: NHD-12864WG-CTFH-VN

Connections:
+5V: P1.1, U1.4 (VDD), U1.19 (LED+)
/CS1: P1.18, U1.2 (CS1B)
/CS2: P1.20, U1.1 (CS2B)
/DB0: P1.16, U1.9 (DB0)
/DB1: P1.14, U1.10 (DB1)
/DB2: P1.12, U1.11 (DB2)
/DB3: P1.10, U1.12 (DB3)
/DB4: P1.8, U1.13 (DB4)
/DB5: P1.6, U1.14 (DB5)
/DB6: P1.4, U1.15 (DB6)
/DB7: P1.2, U1.16 (DB7)
/E: P1.13, U1.8 (E)
/R/W: P1.15, U1.7 (R/W)
/RS: P1.19, U1.6 (RS)
/STATUS_LED: P1.5, R1.1
/USB+: J1.3 (D+), P1.9
/USB-: J1.2 (D-), P1.11
/USB_VCC: J1.1 (Vbus), P1.7
/V0: K1.2 (PM), U1.5 (V0)
/VEE: K1.3, U1.18 (VEE)
/~RST: P1.17, U1.17 (~RST)
GND: D1.2 (K), J1.4 (GND), K1.1, P1.3, U1.3 (VSS), U1.20 (LED-)
unnamed: D1.1 (A), R1.2

Board: 2 copper layers, 10 parts (1 on the bottom side), 23 nets.

Other parts of the board:
1PIN, 1PIN#2, 1PIN#3, 1PIN#4: P***; 1pin

## KiCad design Pcbs/PcbsDefinitivos/testSensoresTension/testSensoresTension.kicad_pcb

Board: 2 copper layers, 12 parts (7 on the bottom side), 14 nets.

Parts:
K1: CONN_3; SIL-3
K2: CONN_3; bornier3
P1: CONN_2; SIL-2
R1, R3, R4: R; SM0805
R2, R5: 10k; SM0805
R6: 1k; SM0805
U1: TL084; SO14E
U2, U3: IL300; DIP-8__300

Connections:
+5V: K1.1, K2.1, R6.2, U1.4, U2.3, U2.6
-5V: K1.3, U1.11
/In: K2.2, R2.2, U1.3
/Out1: P1.1, R4.1, U1.7
/Out2: P1.2, R5.1, U1.8
GND: K1.2, K2.3, R3.1, U1.5, U1.10, U1.12, U2.1, U3.4, U3.5
unnamed: R1.1, U2.2
unnamed: R3.2, U1.2, U2.4
unnamed: R4.2, U1.6, U2.5
unnamed: R1.2, U1.1
unnamed: R6.1, U3.2
unnamed: R5.2, U1.9, U3.6
unnamed: R2.1, U1.13, U3.3
unnamed: U1.14, U3.1

## KiCad design Pcbs/PcbsDefinitivos/AcopladorAccionadoresPotencia/AcopladorAccionadoresPotencia.kicad_pcb

Parts:
C1, C2, C3: 0.1u
D1, D2, D3: LED
P1, P4, P6, P8: CONN_2
P2: CONN_5
Q1, Q2, Q3: 2N7002
R1, R4, R5, R6, R9, R10: 560
R2, R7, R11: 180
R3, R8, R12: 2.2k
R17, R18, R19: 10k
U1, U3, U5: MOC3011
U2, U4, U6: BT136

Connections:
+5V: P2.2, R1.2, R4.2, R5.2, R6.2, R9.2, R10.2
/220v+: P1.1, P4.2 (PM), P6.1, P8.1
/220v-: C1.2, C2.2, C3.2, P4.1, U2.1, U4.1, U6.1
/Contactor_1: P2.3, Q3.G, R19.2
/Contactor_2: P2.4, Q2.G, R18.2
/Contactor_3: P2.5, Q1.G, R17.2
GND: P2.1, Q1.S, Q2.S, Q3.S, R17.1, R18.1, R19.1
unnamed: C1.1, R2.2, R3.1
unnamed: U1.4 (S2), U2.3
unnamed: D1.1 (A), R4.1
unnamed: D1.2 (K), Q1.D, U1.2 (K)
unnamed: R7.1, U3.6 (S1)
unnamed: C2.1, R7.2, R8.1
unnamed: R6.1, U3.1 (A)
unnamed: D2.2 (K), Q2.D, U3.2 (K)
unnamed: U3.4 (S2), U4.3
unnamed: R2.1, U1.6 (S1)
unnamed: R1.1, U1.1 (A)
unnamed: D3.2 (K), Q3.D, U5.2 (K)
unnamed: D3.1 (A), R9.1
unnamed: C3.1, R11.2, R12.1
unnamed: D2.1 (A), R5.1
unnamed: R11.1, U5.6 (S1)
unnamed: R10.1, U5.1 (A)
unnamed: U5.4 (S2), U6.3
unnamed: P6.2 (PM), R8.2, U4.2
unnamed: P1.2 (PM), R3.2, U2.2
unnamed: P8.2 (PM), R12.2, U6.2

Notes on the sheet:
Drivers Contactores

Board: 2 copper layers, 57.1 x 72.4 mm, 39 parts (18 on the bottom side), 28 nets.

Other parts of the board:
1PIN, 1PIN#2, 1PIN#3, 1PIN#4: P***; 1pin

## KiCad design Pcbs/PcbsDefinitivos/Baliza/Baliza.kicad_pcb

Board: 2 copper layers, 56.0 x 65.6 mm, 18 parts (0 on the bottom side), 15 nets.

Parts:
D1, D2, D3, D4: DIODE; SM1206
P1: CON_LIGHT_IN; SIL-6
P2: CON_LIGHT_OUT; bornier5
Q1, Q2, Q3, Q4: MOS_N; SOT23
R1, R2, R3, R4: R; SM0805
RLY1, RLY2, RLY3, RLY4: RELAY_T9AS5X1; relay_JQC-3F-1C

Connections:
+5V: D1.2, D2.2, D3.2, D4.2, P1.2, RLY1.2, RLY2.2, RLY3.2, RLY4.2
/COMMON: P2.1, RLY1.3, RLY2.3, RLY3.3, RLY4.3
/GREEN_LIGHT_IN: P1.3, Q4.1, R1.1
/GREEN_LIGHT_OUT: P2.3, RLY1.4
/RED_LIGHT_IN: P1.5, Q1.1, R2.1
/RED_LIGHT_OUT: P2.5, RLY2.4
/SIREN_IN: P1.6, Q3.1, R3.1
/SIREN_OUT: P2.2, RLY3.4
/YELLOW_LIGHT_IN: P1.4, Q2.1, R4.1
/YELLOW_LIGHT_OUT: P2.4, RLY4.4
GND: P1.1, Q1.2, Q2.2, Q3.2, Q4.2, R1.2, R2.2, R3.2, R4.2
unnamed: D4.1, Q3.3, RLY3.1
unnamed: D3.1, Q2.3, RLY4.1
unnamed: D2.1, Q4.3, RLY1.1
unnamed: D1.1, Q1.3, RLY2.1
